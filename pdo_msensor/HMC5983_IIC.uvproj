# Keil uVision project HMC5983_IIC.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: HMC5983_IIC +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: Custom library
  c include: .\library;..\LSM9DS1_new sensor MCU program
  group Main
    ./: HMC5983_IIC.c
  group Startup
    ./: STARTUP.A51
  group Library
    ./library/: AT24C512.c IIC_Address.c IIC_Function.c Serial.c LSM9DS1_calibration.c
